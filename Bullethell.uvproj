# Keil uVision project Bullethell.uvproj, settings and files
target Bullethell (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Bullethell
  c flags: Optim=1
  c include: ..;..\..\..;..\inc;..\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Library
    ../driverlib/rvmdk/: driverlib.lib
  group Source Code
    ./: ADC.c main.c Startup.s Output.c rit128x96x4.c SysTickInts.c Entities.c Controller.c
